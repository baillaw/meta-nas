RDEPENDS_${PN}_class-native = "python-distribute-native"
BBCLASSEXTEND = " native "
