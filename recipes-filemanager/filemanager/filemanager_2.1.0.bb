require filemanager.inc

SRC_URI[md5sum] = "52112e8e080274069c6b3e1bd581853f"
SRC_URI[sha256sum] = "61712ab6b4c81611aec92fb7248aea69ce52bd424c5046ee24a5024461065e3e"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://scripts/filemanager.min.js;md5=bd498f1cf35a69871ae4dc758a741c89"
