require filemanager.inc
SRCREV = "v2.5.0"
SRC_URI[md5sum] = "52112e8e080274069c6b3e1bd581853f"
SRC_URI[sha256sum] = "61712ab6b4c81611aec92fb7248aea69ce52bd424c5046ee24a5024461065e3e"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://scripts/filemanager.min.js;md5=60e12b4ef4a95077acb24cf99b1690b6"
