FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://start-stop-daemon_gettext.patch"
